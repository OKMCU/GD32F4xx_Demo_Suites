# IAR project GD32450Z_EVAL.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F450xK GD GD32F450xK
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F450
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\GD32F4xx_Firmware_Library\GD32F4xx_standard_peripheral\Include; ..\..\..\..\..\Utilities; ..\inc; ..\..\..\Third_party\lwip-1.4.1\src\include; ..\..\..\Third_party\lwip-1.4.1\src\include\ipv4; ..\..\..\Third_party\lwip-1.4.1\src\include\netif; ..\..\..\Third_party\lwip-1.4.1\src\include\lwip; ..\..\..\Third_party\lwip-1.4.1\port\GD32F4xx; ..\..\..\Third_party\lwip-1.4.1\port\GD32F4xx\FreeRTOS; ..\..\..\Third_party\lwip-1.4.1\port\GD32F4xx\arch; ..\..\..\Third_party\FreeRTOS-8.2.3\include; ..\..\..\Third_party\FreeRTOS-8.2.3\portable\IAR\ARM_CM4F
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.ADefines: USE_STDPERIPH_DRIVER; GD32F4XX
  AARM.AUserIncludes: ..\inc
  OBJCOPY.OOCOutputFile: GD32450Z_EVAL.srec
  ILINK.IlinkOutputFile: GD32F450Z_EVAL.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\GD\GD32F450xK.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group Application
    ../src/: gd32f4xx_enet_eval.c gd32f4xx_it.c hello_gigadevice.c main.c netconf.c tcp_client.c udp_echo.c
  group CMSIS
    ../src/: system_gd32f4xx.c
  group Doc
    ../: readme.txt
  group FreeRTOS
    ../../../Third_party/FreeRTOS-8.2.3/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../Third_party/FreeRTOS-8.2.3/portable/MemMang/: heap_2.c
    ../../../Third_party/FreeRTOS-8.2.3/portable/IAR/ARM_CM4F/: port.c portasm.s
  group GD32F4xx_EVAL
    ../../../../../Utilities/: gd32f450z_eval.c
  group GD32F4xx_Peripherals
    ../../../../../../GD32F4xx_Firmware_Library/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group Lwip
    ../../../Third_party/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../Third_party/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../Third_party/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c lwip_timers.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ../../../Third_party/lwip-1.4.1/src/netif/: etharp.c
  group Lwip_port
    ../../../Third_party/lwip-1.4.1/port/GD32F4xx/FreeRTOS/: ethernetif.c sys_arch.c
  group Startup
    ../../../../../../GD32F4xx_Firmware_Library/CMSIS/GD/GD32F4xx/Source/IAR/: startup_gd32f450.s
