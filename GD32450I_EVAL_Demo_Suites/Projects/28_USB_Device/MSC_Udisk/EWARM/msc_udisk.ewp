# IAR project msc_udisk.ewp, settings and files
configuration USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32F450xG GD GD32F450xG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USB_FS; GD32F450
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\Utilities; ..\..\..\..\..\GD32F4xx_Firmware_Library\CMSIS\GD\GD32F4xx\Include; ..\..\..\..\..\GD32F4xx_Firmware_Library\GD32F4xx_standard_peripheral\Include; ..\..\..\..\..\GD32F4xx_Firmware_Library\GD32F4xx_usb_library\device\class\msc\Include; ..\..\..\..\..\GD32F4xx_Firmware_Library\GD32F4xx_usb_library\device\core\Include; ..\..\..\..\..\GD32F4xx_Firmware_Library\GD32F4xx_usb_library\driver\Include; ..\..\..\..\..\GD32F4xx_Firmware_Library\GD32F4xx_usb_library\ustd\class\msc; ..\..\..\..\..\GD32F4xx_Firmware_Library\GD32F4xx_usb_library\ustd\common
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USB_MSC.srec
  ILINK.IlinkOutputFile: msc_udisk.hex
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration USBHS (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USB_HS; USE_ULPI_PHY; GD32F450
  ICCARM.CCIncludePath2: ..\..\..\..\..\GD32F4xx_Firmware_Library\GD32F4xx_standard_peripheral\Include; ..\..\..\..\..\GD32F4xx_Firmware_Library\CMSIS\GD\GD32F4xx\Include; ..\..\..\..\Utilities; ..\inc; ..\..\..\..\..\GD32F4xx_Firmware_Library\GD32F4xx_usb_library\device\class\msc\Include; ..\..\..\..\..\GD32F4xx_Firmware_Library\GD32F4xx_usb_library\device\core\Include; ..\..\..\..\..\GD32F4xx_Firmware_Library\GD32F4xx_usb_library\driver\Include; ..\..\..\..\..\GD32F4xx_Firmware_Library\GD32F4xx_usb_library\ustd\class\msc; ..\..\..\..\..\GD32F4xx_Firmware_Library\GD32F4xx_usb_library\ustd\common
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\GD\GD32F450xG.icf
  group Application
    ../src/: app.c gd32f4xx_hw.c gd32f4xx_it.c sram_msd.c usbd_storage_msd.c
  group CMSIS
    ../src/: system_gd32f4xx.c
  group Doc
    ../: readme.txt
  group GD32F4xx_EVAL
    ../../../../Utilities/: gd32f450i_eval.c
  group GD32F4xx_StdPeriph
    ../../../../../GD32F4xx_Firmware_Library/GD32F4xx_standard_peripheral/Source/: gd32f4xx_exti.c gd32f4xx_gpio.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_usart.c
  group Startup
    ../../../../../GD32F4xx_Firmware_Library/CMSIS/GD/GD32F4xx/Source/IAR/: startup_gd32f450.s
  group USB_Class
    ../../../../../GD32F4xx_Firmware_Library/GD32F4xx_usb_library/device/class/msc/Source/: usbd_msc_bbb.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group USB_Device
    ../../../../../GD32F4xx_Firmware_Library/GD32F4xx_usb_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Drivers
    ../../../../../GD32F4xx_Firmware_Library/GD32F4xx_usb_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
